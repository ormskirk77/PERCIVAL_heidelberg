* NGSPICE file created from cvxif_pau.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_4 abstract view
.subckt sky130_fd_sc_hd__o41a_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_2 abstract view
.subckt sky130_fd_sc_hd__o41a_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_4 abstract view
.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_2 abstract view
.subckt sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4bb_4 abstract view
.subckt sky130_fd_sc_hd__nand4bb_4 A_N B_N C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

.subckt cvxif_pau VGND VPWR clk issue_ready issue_req_instr[0] issue_req_instr[10]
+ issue_req_instr[11] issue_req_instr[12] issue_req_instr[13] issue_req_instr[14]
+ issue_req_instr[15] issue_req_instr[16] issue_req_instr[17] issue_req_instr[18]
+ issue_req_instr[19] issue_req_instr[1] issue_req_instr[20] issue_req_instr[21] issue_req_instr[22]
+ issue_req_instr[23] issue_req_instr[24] issue_req_instr[25] issue_req_instr[26]
+ issue_req_instr[27] issue_req_instr[28] issue_req_instr[29] issue_req_instr[2] issue_req_instr[30]
+ issue_req_instr[31] issue_req_instr[3] issue_req_instr[4] issue_req_instr[5] issue_req_instr[6]
+ issue_req_instr[7] issue_req_instr[8] issue_req_instr[9] issue_resp_accept issue_resp_register_read[1]
+ issue_valid register_rs0[0] register_rs0[10] register_rs0[11] register_rs0[12] register_rs0[13]
+ register_rs0[14] register_rs0[15] register_rs0[16] register_rs0[17] register_rs0[18]
+ register_rs0[19] register_rs0[1] register_rs0[20] register_rs0[21] register_rs0[22]
+ register_rs0[23] register_rs0[24] register_rs0[25] register_rs0[26] register_rs0[27]
+ register_rs0[28] register_rs0[29] register_rs0[2] register_rs0[30] register_rs0[31]
+ register_rs0[3] register_rs0[4] register_rs0[5] register_rs0[6] register_rs0[7]
+ register_rs0[8] register_rs0[9] register_rs1[0] register_rs1[10] register_rs1[11]
+ register_rs1[12] register_rs1[13] register_rs1[14] register_rs1[15] register_rs1[16]
+ register_rs1[17] register_rs1[18] register_rs1[19] register_rs1[1] register_rs1[20]
+ register_rs1[21] register_rs1[22] register_rs1[23] register_rs1[24] register_rs1[25]
+ register_rs1[26] register_rs1[27] register_rs1[28] register_rs1[29] register_rs1[2]
+ register_rs1[30] register_rs1[31] register_rs1[3] register_rs1[4] register_rs1[5]
+ register_rs1[6] register_rs1[7] register_rs1[8] register_rs1[9] register_rs_valid[0]
+ register_rs_valid[1] register_valid result_data[0] result_data[10] result_data[11]
+ result_data[12] result_data[13] result_data[14] result_data[15] result_data[16]
+ result_data[17] result_data[18] result_data[19] result_data[1] result_data[2] result_data[30]
+ result_data[31] result_data[3] result_data[4] result_data[5] result_data[6] result_data[7]
+ result_data[8] result_data[9] result_ready result_valid rst result_data[20] result_data[29]
+ result_data[28] result_data[27] result_data[26] register_ready result_data[25] result_data[24]
+ result_data[23] issue_resp_writeback result_data[22] result_data[21] issue_resp_register_read[0]
X_2037_ _1071_ _1075_ _0081_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2106_ _0060_ _0065_ _0110_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1270_ _0414_ _0422_ _0419_ _0420_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__nand4_2
X_1606_ _0758_ _0759_ _0546_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1537_ _0386_ _0392_ _0689_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__mux2_1
X_1399_ _0425_ _0470_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a21o_1
X_1468_ _0415_ _0408_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1253_ u_posit_add.in2\[7\] u_posit_add.in2\[6\] u_posit_add.in2\[5\] u_posit_add.in2\[4\]
+ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__or4_1
X_1322_ _0445_ _0461_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__xnor2_1
X_1184_ _0333_ _0335_ _0336_ _0337_ u_posit_add.in1\[15\] VGND VGND VPWR VPWR _0338_
+ sky130_fd_sc_hd__o41a_4
XTAP_TAPCELL_ROW_19_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1940_ _1091_ _1093_ _1071_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__mux2_1
X_1871_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1236_ _0384_ _0387_ _0389_ _0380_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__a31o_2
X_2354_ clknet_2_0__leaf_clk _0001_ VGND VGND VPWR VPWR current_state\[0\] sky130_fd_sc_hd__dfxtp_1
X_2285_ _0292_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_1305_ _0413_ _0458_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__xnor2_1
X_1167_ net50 op net49 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_51_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2070_ _0113_ _0114_ _0045_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1923_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_44_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1785_ _0936_ _0937_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nor2_1
X_1854_ _1006_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2199_ _0233_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__xor2_1
X_2268_ _0283_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_1219_ _0371_ _0362_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__xnor2_1
X_2337_ clknet_2_1__leaf_clk _0025_ VGND VGND VPWR VPWR u_posit_add.in1\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_47_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xcvxif_pau_75 VGND VGND VPWR VPWR cvxif_pau_75/HI result_data[16] sky130_fd_sc_hd__conb_1
Xcvxif_pau_86 VGND VGND VPWR VPWR cvxif_pau_86/HI result_data[27] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_41_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1570_ _0687_ _0703_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a21oi_1
X_2122_ _0139_ _0165_ _0111_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__mux2_1
X_2053_ _1070_ _0071_ _0097_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_49_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1837_ _0892_ _0956_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__xor2_2
X_1906_ _0984_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1768_ _0844_ _0676_ _0726_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1699_ _0672_ _0750_ _0686_ _0675_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput64 net64 VGND VGND VPWR VPWR result_data[1] sky130_fd_sc_hd__buf_1
XFILLER_0_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1622_ _0727_ _0750_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__a21oi_1
X_1484_ _0455_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__inv_2
X_1553_ _0468_ _0706_ _0479_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__mux2_1
X_2105_ _0147_ _0149_ _0067_ _0119_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__and4_1
X_2036_ _1071_ _0075_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1605_ _0613_ _0689_ _0615_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__a21oi_1
X_1536_ _0503_ _0399_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1398_ _0468_ _0470_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nor2_1
X_1467_ _0618_ _0606_ _0607_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2019_ _1124_ _0063_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1252_ u_posit_add.in2\[0\] u_posit_add.in2\[3\] u_posit_add.in2\[2\] u_posit_add.in2\[1\]
+ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__or4_2
X_1321_ _0466_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__nand2_1
X_1183_ u_posit_add.in1\[13\] u_posit_add.in1\[12\] VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_19_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1519_ _0655_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__and2_2
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1870_ _1021_ _1022_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2353_ _0000_ _0005_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_35_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1235_ _0340_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nand2_1
X_1166_ _0316_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__inv_2
X_2284_ net26 u_posit_add.in1\[3\] _0280_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__mux2_1
X_1304_ u_posit_add.in2\[5\] _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_19_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ _0041_ _0043_ _1133_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__mux2_2
XFILLER_0_30_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1922_ _1073_ _1075_ _1071_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1784_ _0936_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__and2_1
X_1853_ _0899_ _0918_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2336_ clknet_2_1__leaf_clk _0024_ VGND VGND VPWR VPWR u_posit_add.in1\[1\] sky130_fd_sc_hd__dfxtp_2
X_2198_ _0219_ _0221_ _0227_ _0132_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__o31ai_1
X_2267_ net36 u_posit_add.in2\[12\] _0280_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__mux2_1
X_1218_ _0371_ _0359_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xcvxif_pau_87 VGND VGND VPWR VPWR cvxif_pau_87/HI result_data[28] sky130_fd_sc_hd__conb_1
Xcvxif_pau_76 VGND VGND VPWR VPWR cvxif_pau_76/HI result_data[17] sky130_fd_sc_hd__conb_1
XFILLER_0_53_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2052_ _1052_ _1050_ _1070_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a21oi_1
X_2121_ _0146_ _0164_ _0105_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__mux2_1
X_1905_ _1052_ _1041_ _1046_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__nor3_2
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1836_ _0987_ _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__or2_1
X_1767_ _0843_ _0866_ _0876_ _0889_ _0877_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__a41o_1
XFILLER_0_44_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1698_ _0677_ _0680_ _0724_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2319_ clknet_2_2__leaf_clk _0007_ VGND VGND VPWR VPWR u_posit_add.in2\[1\] sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_55_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput65 net65 VGND VGND VPWR VPWR result_data[2] sky130_fd_sc_hd__buf_1
XFILLER_0_37_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput54 net54 VGND VGND VPWR VPWR issue_ready sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_46_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1621_ _0751_ _0763_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1552_ _0470_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__inv_2
X_2104_ _0148_ _0142_ _0138_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__mux2_1
X_1483_ _0559_ _0634_ _0635_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_52_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2035_ _0074_ _0079_ _1041_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1819_ _0940_ _0944_ _0972_ _0938_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a31o_1
XFILLER_0_58_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1535_ _0596_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__buf_2
X_1604_ _0359_ _0689_ _0608_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__a21oi_1
X_1397_ u_posit_add.in2\[0\] _0472_ _0445_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a21oi_1
X_1466_ _0594_ _0606_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2018_ _1120_ _1121_ _1125_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1320_ _0445_ _0468_ _0470_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__o31a_1
X_1182_ u_posit_add.in1\[11\] u_posit_add.in1\[9\] u_posit_add.in1\[8\] u_posit_add.in1\[10\]
+ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__or4_2
X_1251_ _0340_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1518_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__clkbuf_4
X_1449_ _0503_ _0596_ _0545_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2352_ clknet_2_0__leaf_clk _0040_ VGND VGND VPWR VPWR pau_wait_counter\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2283_ _0291_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1303_ u_posit_add.in2\[4\] _0415_ _0411_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__o21a_1
X_1234_ u_posit_add.in1\[4\] _0385_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__xnor2_1
X_1165_ _0320_ _0322_ net53 VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_42_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1998_ _0041_ _0042_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1921_ _1004_ _1074_ _1054_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__mux2_1
X_1852_ _0928_ _0900_ _0895_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_16_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1783_ _0797_ _0799_ _0751_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2266_ _0282_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_2335_ clknet_2_1__leaf_clk _0023_ VGND VGND VPWR VPWR u_posit_add.in1\[0\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2197_ _0231_ _0232_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__nand2_1
X_1217_ _0348_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__buf_6
XFILLER_0_15_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xcvxif_pau_88 VGND VGND VPWR VPWR cvxif_pau_88/HI result_data[29] sky130_fd_sc_hd__conb_1
Xcvxif_pau_77 VGND VGND VPWR VPWR cvxif_pau_77/HI result_data[18] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_49_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ _1133_ _0096_ _0135_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__mux2_1
X_2051_ _0094_ _0095_ _0042_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1904_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__inv_2
X_1835_ _0988_ _0962_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1766_ _0877_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__or2_1
X_1697_ _0775_ _0679_ _0727_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__and3b_1
XFILLER_0_12_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2318_ clknet_2_0__leaf_clk _0006_ VGND VGND VPWR VPWR u_posit_add.in2\[0\] sky130_fd_sc_hd__dfxtp_2
X_2249_ _0273_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_55_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput66 net66 VGND VGND VPWR VPWR result_data[3] sky130_fd_sc_hd__buf_1
Xoutput55 net55 VGND VGND VPWR VPWR issue_resp_accept sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_46_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1620_ _0591_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and2b_1
X_1482_ _0427_ _0569_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__and2_1
X_1551_ _0559_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__nor2_1
X_2103_ _0123_ _0120_ _0135_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2034_ _1100_ _1072_ _0078_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__o21a_1
X_1818_ _0948_ _0965_ _0970_ _0968_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a311o_1
XFILLER_0_17_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1749_ _0844_ _0886_ _0887_ _0841_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1603_ _0755_ _0756_ _0599_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__mux2_1
X_1465_ _0607_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__or2_1
X_1534_ _0594_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2017_ _1133_ _0061_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__nand2_2
X_1396_ _0456_ _0459_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__or2b_1
XFILLER_0_9_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1181_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__buf_6
X_1250_ _0369_ _0376_ _0390_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_19_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1517_ _0584_ _0656_ _0665_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__o31a_1
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1448_ _0369_ _0376_ _0390_ _0403_ _0392_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__o221a_1
XFILLER_0_37_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1379_ _0488_ _0527_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2351_ clknet_2_0__leaf_clk _0039_ VGND VGND VPWR VPWR pau_wait_counter\[0\] sky130_fd_sc_hd__dfxtp_1
X_1233_ _0371_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nand2_1
X_2282_ net25 u_posit_add.in1\[2\] _0280_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__mux2_1
X_1302_ _0413_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1164_ current_state\[0\] net73 current_state\[2\] _0321_ VGND VGND VPWR VPWR _0322_
+ sky130_fd_sc_hd__or4b_1
X_1997_ _1116_ _1146_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1920_ _0983_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__inv_2
X_1851_ _0976_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1782_ _0928_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2196_ _0224_ _0226_ _0230_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__or3b_2
X_2265_ net35 u_posit_add.in2\[11\] _0280_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1216_ _0340_ _0357_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__nand2_1
X_2334_ clknet_2_0__leaf_clk _0022_ VGND VGND VPWR VPWR op sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xcvxif_pau_89 VGND VGND VPWR VPWR cvxif_pau_89/HI result_data[30] sky130_fd_sc_hd__conb_1
Xcvxif_pau_78 VGND VGND VPWR VPWR cvxif_pau_78/HI result_data[19] sky130_fd_sc_hd__conb_1
XFILLER_0_21_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ _1112_ _1146_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1903_ _0991_ _0993_ _1056_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__mux2_1
X_1834_ _0964_ _0953_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__or2b_1
X_1765_ _0916_ _0917_ _0918_ _0899_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_4_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1696_ _0676_ _0848_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nand3_1
X_2179_ _1133_ _0173_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__nand2_2
X_2317_ _0310_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_2248_ net42 u_posit_add.in2\[3\] _0269_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput67 net67 VGND VGND VPWR VPWR result_data[4] sky130_fd_sc_hd__buf_1
Xoutput56 net56 VGND VGND VPWR VPWR issue_resp_register_read[1] sky130_fd_sc_hd__buf_1
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1550_ u_posit_add.in2\[0\] _0485_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__nand2_1
X_1481_ _0573_ _0624_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__nand2_2
X_2102_ _0146_ _0136_ _0138_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__mux2_1
X_2033_ _1077_ _0077_ _1081_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1817_ _0942_ _0943_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1748_ _0844_ _0879_ _0880_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__nor3_1
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1679_ _0831_ _0832_ _0687_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_8_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1602_ _0386_ _0689_ _0600_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1464_ _0567_ _0609_ _0612_ _0616_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a32o_1
X_1395_ _0547_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__nor2_1
X_1533_ _0591_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__buf_2
X_2016_ _0041_ _0042_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1180_ u_posit_add.in1\[7\] u_posit_add.in1\[5\] u_posit_add.in1\[4\] u_posit_add.in1\[6\]
+ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__or4_1
XFILLER_0_54_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1516_ _0661_ _0664_ _0668_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a211o_1
XFILLER_0_10_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1447_ _0386_ _0596_ _0599_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__a211o_1
X_1378_ _0521_ _0500_ _0502_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor4b_1
XFILLER_0_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1232_ u_posit_add.in1\[4\] _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xor2_4
X_2281_ _0290_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_2350_ clknet_2_2__leaf_clk _0038_ VGND VGND VPWR VPWR u_posit_add.in1\[15\] sky130_fd_sc_hd__dfxtp_2
X_1301_ u_posit_add.in2\[6\] _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__xor2_4
XFILLER_0_59_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1163_ pau_wait_counter\[1\] pau_wait_counter\[0\] current_state\[1\] VGND VGND VPWR
+ VPWR _0321_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1996_ _1120_ _1121_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload0 clknet_2_1__leaf_clk VGND VGND VPWR VPWR clkload0/X sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1850_ _0981_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__inv_2
X_1781_ _0934_ _0908_ _0910_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_21_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2333_ clknet_2_2__leaf_clk _0021_ VGND VGND VPWR VPWR u_posit_add.in2\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2195_ _0224_ _0226_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__o21bai_1
X_2264_ _0281_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1215_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1979_ _1130_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_15_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xcvxif_pau_79 VGND VGND VPWR VPWR cvxif_pau_79/HI result_data[20] sky130_fd_sc_hd__conb_1
XFILLER_0_38_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1902_ _1017_ _1050_ _1053_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__o21a_2
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1833_ _0985_ _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__xnor2_2
X_1764_ _0676_ _0726_ _0777_ _0844_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__o211a_1
X_1695_ _0727_ _0750_ _0801_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a21o_1
X_2316_ _0328_ _0267_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__and3_1
X_2178_ _0216_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
X_2247_ _0272_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput57 net57 VGND VGND VPWR VPWR result_data[0] sky130_fd_sc_hd__buf_1
XFILLER_0_43_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput68 net68 VGND VGND VPWR VPWR result_data[5] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_46_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ _0431_ _0633_ _0485_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2101_ _0103_ _0086_ _0135_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__mux2_1
X_2032_ _0075_ _0076_ _1071_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1816_ _0968_ _0969_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1747_ _0781_ _0825_ _0836_ _0686_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__or4b_1
X_1678_ _0688_ _0606_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1532_ _0683_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__nor2_1
X_1601_ _0610_ _0689_ _0611_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1394_ _0371_ _0404_ _0546_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21oi_1
X_1463_ _0351_ _0546_ _0567_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a21oi_1
X_2015_ _1149_ _0044_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__nor2_4
XFILLER_0_45_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1515_ _0666_ _0667_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1446_ _0369_ _0376_ _0390_ _0403_ _0382_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o221a_1
XFILLER_0_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1377_ _0489_ _0491_ _0525_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_18_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1231_ _0377_ _0349_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__and2_2
X_2280_ net24 u_posit_add.in1\[1\] _0280_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__mux2_1
X_1162_ net52 net73 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__or2b_1
XFILLER_0_19_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1300_ u_posit_add.in2\[5\] u_posit_add.in2\[4\] _0406_ u_posit_add.in2\[15\] VGND
+ VGND VPWR VPWR _0454_ sky130_fd_sc_hd__o31a_1
XFILLER_0_59_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1995_ _1117_ _1148_ _1133_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__mux2_4
XFILLER_0_42_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1429_ _0577_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_2_2__leaf_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_21_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1780_ _0905_ _0927_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nand2b_1
X_2332_ clknet_2_3__leaf_clk _0020_ VGND VGND VPWR VPWR u_posit_add.in2\[14\] sky130_fd_sc_hd__dfxtp_4
XFILLER_0_46_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2194_ _0151_ _0165_ _0217_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__a21boi_1
X_2263_ net34 u_posit_add.in2\[10\] _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__mux2_1
X_1214_ _0353_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1978_ _0414_ _0340_ _1131_ _0663_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__a31o_2
XFILLER_0_21_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1901_ _0894_ _0898_ _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__mux2_1
X_1832_ _0947_ _0963_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1763_ _0781_ _0795_ _0814_ _0841_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_40_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1694_ _0677_ _0680_ _0793_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2315_ pau_wait_counter\[0\] _0306_ pau_wait_counter\[1\] VGND VGND VPWR VPWR _0309_
+ sky130_fd_sc_hd__a21o_1
X_2246_ net41 u_posit_add.in2\[2\] _0269_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__mux2_1
X_2177_ _0130_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput69 net69 VGND VGND VPWR VPWR result_data[6] sky130_fd_sc_hd__buf_1
Xoutput58 net58 VGND VGND VPWR VPWR result_data[10] sky130_fd_sc_hd__buf_1
XFILLER_0_9_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2100_ _0140_ _0141_ _0144_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__and3_1
X_2031_ _1062_ _1063_ _1056_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1815_ _0966_ _0967_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1746_ _0899_ _0882_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__and2_2
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1677_ _0643_ _0632_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__or2_1
X_2229_ _0132_ _0259_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_51_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1531_ u_posit_add.in1\[14\] _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__nor2_1
X_1462_ _0613_ _0596_ _0546_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__a211o_1
X_1600_ _0752_ _0753_ _0599_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1393_ _0371_ _0404_ _0546_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__and3_1
X_2014_ _0051_ _0058_ _0045_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1729_ _0836_ _0823_ _0856_ _0825_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1514_ _0666_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1445_ _0597_ _0598_ _0369_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_2_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1376_ _0493_ _0528_ _0507_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__nand4_1
XFILLER_0_33_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1161_ _0318_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__inv_2
X_1230_ _0380_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1994_ _1112_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1428_ _0580_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_38_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1359_ u_posit_add.in2\[10\] _0430_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__xor2_2
XFILLER_0_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload2 clknet_2_3__leaf_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_56_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2331_ clknet_2_3__leaf_clk _0019_ VGND VGND VPWR VPWR u_posit_add.in2\[13\] sky130_fd_sc_hd__dfxtp_1
X_1213_ _0358_ _0360_ _0365_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__o211a_1
X_2262_ _0268_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2193_ _0227_ _0228_ _0229_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1977_ _0535_ _0562_ _0576_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_57_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1831_ _0953_ _0962_ _0964_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__a21oi_1
X_1900_ _1017_ _1050_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_44_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1762_ _0844_ _0826_ _0835_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__and3_1
X_1693_ _0675_ _0845_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__or3_1
X_2176_ _0213_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2314_ _0321_ _0307_ _0308_ _0328_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__o211a_1
X_2245_ _0271_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput59 net59 VGND VGND VPWR VPWR result_data[11] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ _0976_ _0974_ _1056_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1814_ _0966_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__and2_1
X_1745_ _0673_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__buf_2
XFILLER_0_4_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1676_ _0677_ _0680_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__or3_1
X_2159_ _0160_ _0198_ _0199_ _0172_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__o211a_1
X_2228_ _0250_ _0251_ _0238_ _0239_ _0245_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_51_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1530_ _0349_ _0335_ _0336_ _0337_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__or4_1
X_1461_ _0369_ _0376_ _0390_ _0403_ _0614_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o221a_1
X_1392_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2013_ _0054_ _0057_ _1134_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1728_ _0781_ _0879_ _0880_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__o31a_1
XFILLER_0_13_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1659_ _0727_ _0679_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_5_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1513_ _0578_ _0579_ _0581_ _0660_ _0490_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__a41o_1
X_1444_ _0539_ _0542_ _0543_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a21oi_1
X_1375_ _0471_ u_posit_add.in1\[0\] _0468_ _0397_ _0508_ VGND VGND VPWR VPWR _0529_
+ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_2_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1160_ _0319_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1993_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_41_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_50_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1427_ _0575_ _0568_ _0561_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__mux2_1
X_1358_ _0500_ _0501_ _0511_ _0499_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_38_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1289_ u_posit_add.in2\[8\] _0435_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2192_ _0227_ _0228_ _0172_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o21ai_1
X_2330_ clknet_2_3__leaf_clk _0018_ VGND VGND VPWR VPWR u_posit_add.in2\[12\] sky130_fd_sc_hd__dfxtp_2
X_2261_ _0279_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_1212_ _0339_ _0362_ _0364_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_35_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1976_ _1127_ _1128_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1830_ _0976_ _0974_ _0981_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__and4_1
X_1761_ _0877_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1692_ _0672_ _0750_ _0748_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a21oi_1
X_2313_ current_state\[1\] _0306_ pau_wait_counter\[0\] VGND VGND VPWR VPWR _0308_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2175_ _0205_ _0206_ _0160_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__a21oi_1
X_2244_ net40 u_posit_add.in2\[1\] _0269_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1959_ _0931_ _0646_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_1744_ _0876_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1813_ _0785_ _0786_ _0751_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__mux2_1
X_1675_ _0827_ _0828_ _0687_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ _0112_ _0126_ _0130_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__o211a_1
X_2158_ _0133_ _0197_ _0196_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2227_ _0257_ _0258_ _0251_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1391_ _0538_ _0544_ _0369_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__mux2_1
X_1460_ u_posit_add.in1\[11\] _0344_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__xor2_1
X_2012_ _0056_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1727_ _0675_ _0681_ _0686_ _0783_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a31o_1
X_1658_ _0807_ _0811_ _0687_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ _0400_ _0689_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_36_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1512_ _0535_ _0562_ _0576_ _0663_ _0489_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__a41o_1
X_1443_ _0353_ _0536_ _0537_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a21oi_1
X_1374_ _0505_ _0504_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__and2b_1
XFILLER_0_33_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1992_ _1115_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1426_ _0578_ _0579_ _0490_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a21o_1
X_1357_ _0379_ _0455_ _0497_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a21oi_1
X_1288_ _0429_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_38_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2191_ _0219_ _0221_ _0133_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o21a_1
X_2260_ net48 u_posit_add.in2\[9\] _0269_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__mux2_1
X_1211_ _0339_ _0362_ _0364_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_35_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1975_ _0577_ _0664_ _1100_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1409_ _0535_ _0562_ _0489_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_53_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1760_ _0911_ _0912_ _0913_ _0899_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_37_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1691_ _0812_ _0679_ _0727_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__and3b_1
X_2312_ pau_wait_counter\[0\] _0306_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__nand2_1
X_2174_ _0211_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nand2_1
X_2243_ _0270_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1958_ _1110_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nor2b_1
X_1889_ _0683_ _0685_ _1037_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_54_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1743_ _0895_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__nand2_1
X_1812_ _0934_ _0907_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1674_ _0688_ _0694_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__nand2_1
X_2226_ _0173_ _0202_ _0217_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__o21a_1
X_2088_ _0132_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__buf_2
X_2157_ _0196_ _0197_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1390_ _0539_ _0542_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21o_1
X_2011_ _0998_ _0055_ _0052_ _1041_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1726_ _0851_ _0852_ _0728_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__o21a_1
X_1657_ _0808_ _0809_ _0810_ _0607_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__a2bb2o_1
X_1588_ _0595_ _0739_ _0741_ _0688_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__o211a_1
X_2209_ _0224_ _0237_ _0225_ _0230_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1511_ _0661_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__xor2_2
X_1442_ _0369_ _0376_ _0390_ _0403_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_4_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1373_ _0489_ _0491_ _0495_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1709_ _0727_ _0750_ _0788_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1991_ _1114_ _1096_ _1056_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1425_ _0560_ _0549_ _0561_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1287_ _0433_ _0434_ _0439_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and4_2
X_1356_ _0500_ _0502_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__or3_1
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2190_ _0224_ _0226_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__xor2_2
X_1210_ u_posit_add.in1\[9\] _0363_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__xor2_2
XFILLER_0_55_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1974_ _0577_ _1100_ _0664_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_35_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1408_ _0549_ _0560_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__mux2_2
X_1339_ _0450_ _0342_ _0427_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_32_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1690_ _0783_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__buf_2
X_2311_ net73 _0327_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__nor2_1
X_2242_ net33 u_posit_add.in2\[0\] _0269_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__mux2_1
X_2173_ _0200_ _0204_ _0210_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__o21bai_1
X_1957_ _1108_ _1109_ _1056_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1888_ _1030_ _1031_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_54_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1811_ _0953_ _0962_ _0963_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a211o_1
X_1742_ _0843_ _0866_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1673_ _0624_ _0712_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__nand2_1
X_2225_ _0173_ _0202_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2156_ _0187_ _0188_ _0179_ _0180_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_51_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2087_ _0416_ _0931_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a21o_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2010_ _1041_ _1054_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1725_ _0845_ _0846_ _0675_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1656_ _0599_ _0567_ _0753_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__or3b_1
X_1587_ _0595_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nand2_1
X_2139_ _0133_ _0180_ _0179_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__a21o_1
X_2208_ _0242_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1510_ _0662_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__xnor2_2
X_1441_ _0564_ _0566_ _0353_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1372_ _0522_ _0524_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1708_ _0677_ _0680_ _0833_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__or3_1
XFILLER_0_5_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1639_ _0790_ _0792_ _0687_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1990_ _1141_ _1143_ _1135_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1424_ _0487_ _0405_ _0561_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__mux2_2
X_1355_ _0506_ _0507_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_38_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1286_ _0425_ _0436_ _0438_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1973_ _1120_ _1121_ _1124_ _1126_ _1123_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_35_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1407_ _0533_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__clkbuf_4
X_1338_ _0351_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__inv_2
X_1269_ _0419_ _0420_ _0413_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__a211o_1
XFILLER_0_46_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2172_ _0200_ _0204_ _0210_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__or3b_2
X_2310_ _0305_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
X_2241_ _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_4
X_1956_ _1056_ _1108_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__and3_1
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1887_ _1034_ _1038_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_22_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1810_ _0951_ _0952_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nor2_1
X_1741_ _0416_ _0377_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__xor2_4
XFILLER_0_25_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1672_ _0819_ _0824_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2155_ _0187_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__xnor2_2
X_2224_ _0256_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2086_ _0931_ _0377_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__and2b_1
XFILLER_0_33_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1939_ _0983_ _1092_ _1054_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_48_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1724_ _0843_ _0866_ _0876_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1586_ _0700_ _0696_ _0546_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__mux2_1
X_1655_ _0695_ _0609_ _0612_ _0607_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__a31o_1
X_2069_ _1107_ _1141_ _1135_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__mux2_1
X_2138_ _0179_ _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_1
X_2207_ _0240_ _0130_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__and3b_1
XFILLER_0_48_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1440_ _0592_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__or2_1
X_1371_ _0427_ _0492_ _0494_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1707_ _0859_ _0860_ _0825_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__a21o_1
X_1638_ _0688_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1569_ _0591_ _0722_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_1_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1423_ _0563_ _0576_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__xnor2_4
X_1354_ _0463_ _0392_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nand2_1
X_1285_ _0425_ _0436_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_38_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1972_ _1122_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1268_ u_posit_add.in2\[13\] _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__xnor2_1
X_1337_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__inv_2
X_1406_ _0480_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__xnor2_1
X_1199_ _0346_ _0347_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2171_ _0173_ _0184_ _0208_ _0209_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__a31o_1
X_2240_ net53 _0267_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__or2_2
X_1955_ _0535_ _1059_ _1068_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1886_ _0877_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1740_ _0892_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__nand2_1
X_1671_ _0728_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__buf_2
XFILLER_0_25_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2154_ _0173_ _0184_ _0193_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a31o_2
X_2085_ _1059_ _0128_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a21oi_4
X_2223_ _0254_ _0255_ _0130_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__and3b_1
XFILLER_0_16_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1938_ _0987_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__inv_2
X_1869_ _1021_ _1022_ _1010_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1723_ _0416_ _0377_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_13_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1654_ _0567_ _0601_ _0603_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__and3_1
X_2206_ _0132_ _0239_ _0238_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1585_ _0546_ _0699_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a21boi_1
X_2137_ _0161_ _0127_ _0168_ _0169_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__a22o_1
X_2068_ _0091_ _1098_ _1135_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1370_ _0516_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1706_ _0727_ _0679_ _0829_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1637_ _0757_ _0754_ _0567_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1499_ _0588_ _0589_ _0586_ _0587_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_1_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1568_ _0643_ _0712_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1422_ _0568_ _0575_ _0561_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__mux2_2
XFILLER_0_2_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1353_ _0463_ _0392_ _0472_ _0503_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__o22a_1
X_1284_ u_posit_add.in2\[7\] _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1971_ _1108_ _1119_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1405_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__buf_2
XFILLER_0_23_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1267_ u_posit_add.in2\[12\] _0415_ _0408_ _0409_ _0416_ VGND VGND VPWR VPWR _0421_
+ sky130_fd_sc_hd__o41a_2
X_1336_ _0414_ _0340_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nor2_2
X_1198_ _0348_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__xnor2_2
Xinput1 issue_req_instr[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2170_ _0173_ _0149_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nor2_1
X_1954_ _1059_ _1068_ _0535_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1885_ _1036_ _1035_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2299_ net18 u_posit_add.in1\[10\] _0293_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__mux2_1
X_1319_ _0471_ u_posit_add.in2\[1\] _0414_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a211o_1
XFILLER_0_19_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1670_ _0677_ _0680_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__or3_1
XFILLER_0_25_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2222_ _0252_ _0253_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__nand2_1
X_2153_ _0111_ _0141_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__nor2_1
X_2084_ _0416_ _0683_ _0685_ _0377_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1937_ _1090_ _1000_ _1054_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1799_ _0951_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nand2_1
X_1868_ _0763_ _0773_ _0931_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1722_ _0841_ _0871_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1584_ _0599_ _0691_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nand2_1
X_1653_ _0574_ _0803_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__o21ai_1
X_2205_ _0132_ _0238_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2067_ _0067_ _0106_ _0111_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__mux2_1
X_2136_ _0168_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1705_ _0677_ _0680_ _0818_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__or3b_1
XFILLER_0_26_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1636_ _0644_ _0771_ _0765_ _0713_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a22oi_2
X_1567_ _0713_ _0715_ _0720_ _0644_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a22o_1
X_2119_ _0161_ _0127_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1498_ _0649_ _0650_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_1_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1421_ _0570_ _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__xnor2_1
X_1352_ _0472_ _0503_ _0504_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__a22o_1
X_1283_ u_posit_add.in2\[6\] u_posit_add.in2\[5\] u_posit_add.in2\[4\] _0415_ _0411_
+ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__o41a_1
XFILLER_0_18_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1619_ _0574_ _0765_ _0768_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1970_ _1122_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1335_ _0414_ _0340_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand2_2
X_1404_ _0550_ _0555_ _0557_ _0442_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_23_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput2 issue_req_instr[12] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_39_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1266_ _0417_ _0418_ u_posit_add.in2\[11\] VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a21o_1
X_1197_ u_posit_add.in1\[12\] _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_34_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1953_ _1095_ _1106_ _1097_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1884_ _1030_ _1031_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_31_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2298_ _0299_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_1318_ u_posit_add.in2\[2\] _0467_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__xor2_4
X_1249_ _0395_ _0402_ _0353_ _0367_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_19_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2152_ _0138_ _0124_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__nand2_1
X_2221_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2083_ _1071_ _0076_ _1103_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_17_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1936_ _0989_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__inv_2
X_1867_ _1019_ _1020_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__xnor2_1
X_1798_ _0828_ _0827_ _0751_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_44_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1721_ _0844_ _0872_ _0873_ _0874_ _0673_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a311o_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1583_ _0729_ _0731_ _0733_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__o211ai_1
X_1652_ _0635_ _0804_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_53_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2135_ _0173_ _0176_ _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__a21oi_2
X_2204_ _0231_ _0232_ _0219_ _0221_ _0227_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_28_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2066_ _0060_ _0065_ _0110_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a21o_2
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1919_ _0987_ _0989_ _1054_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1704_ _0825_ _0857_ _0781_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_26_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1497_ _0535_ _0578_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__and2b_1
X_1635_ _0677_ _0680_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__or3_1
X_1566_ _0717_ _0719_ _0710_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__mux2_1
X_2118_ _0127_ _0134_ _0162_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__a21o_1
X_2049_ _1133_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1351_ _0471_ u_posit_add.in1\[0\] _0470_ _0399_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__a22o_1
X_1420_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__buf_2
XFILLER_0_25_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1282_ u_posit_add.in2\[8\] _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__xor2_4
XFILLER_0_58_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1618_ _0574_ _0771_ _0624_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1549_ _0688_ _0694_ _0698_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_37_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1265_ u_posit_add.in2\[11\] _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand3_2
X_1403_ _0429_ _0556_ _0449_ _0451_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o2bb2a_1
X_1334_ _0445_ _0340_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1196_ _0349_ _0335_ _0336_ u_posit_add.in1\[15\] VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__o31a_2
Xinput3 issue_req_instr[13] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1952_ _1101_ _1102_ _1103_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1883_ _1035_ _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_31_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2297_ net32 u_posit_add.in1\[9\] _0293_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1248_ _0340_ _0397_ _0399_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__a31o_1
X_1317_ u_posit_add.in2\[0\] VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1179_ u_posit_add.in1\[0\] u_posit_add.in1\[1\] u_posit_add.in1\[3\] u_posit_add.in1\[2\]
+ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__or4_2
XFILLER_0_34_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2082_ _0112_ _0126_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__nand2_1
X_2151_ _0192_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
X_2220_ _0238_ _0239_ _0245_ _0132_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o31a_1
XFILLER_0_17_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1935_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__inv_2
X_1797_ _0950_ _0925_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__xnor2_1
X_1866_ _0877_ _1007_ _1006_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o21ai_1
Xinput50 register_rs_valid[1] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
XFILLER_0_39_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2349_ clknet_2_0__leaf_clk _0037_ VGND VGND VPWR VPWR u_posit_add.in1\[14\] sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_50_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1720_ _0681_ _0686_ _0725_ _0676_ _0780_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__o2111a_1
X_1651_ _0710_ _0574_ _0770_ _0624_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1582_ _0625_ _0624_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__or3_1
X_2134_ _0111_ _0144_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__nor2_1
X_2203_ _0232_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__xor2_2
X_2065_ _0108_ _0109_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1918_ _1055_ _1058_ _1071_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__mux2_1
X_1849_ _0984_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1703_ _0836_ _0823_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a21o_1
X_1634_ _0751_ _0785_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21oi_1
X_1496_ _0535_ _0578_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_18_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1565_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__inv_2
X_2117_ _0159_ _0130_ _0160_ _0161_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__and4b_1
X_2048_ _0086_ _0092_ _0045_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1350_ _0470_ _0399_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__or2_1
X_1281_ _0415_ _0408_ _0411_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__o21a_2
XFILLER_0_58_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1617_ _0769_ _0770_ _0559_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1479_ _0514_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__inv_2
XFILLER_0_5_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1548_ _0567_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1402_ _0433_ _0434_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1264_ u_posit_add.in2\[10\] u_posit_add.in2\[9\] _0416_ VGND VGND VPWR VPWR _0418_
+ sky130_fd_sc_hd__o21ai_1
X_1333_ _0480_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nor2_1
Xinput4 issue_req_instr[14] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1195_ _0333_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__buf_2
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1951_ _1104_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1882_ _0841_ _0901_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_31_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2296_ _0298_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_1178_ _0316_ _0318_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__nor2_1
X_1247_ _0400_ u_posit_add.in1\[1\] _0340_ _0397_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a211oi_1
X_1316_ u_posit_add.in2\[1\] _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xor2_4
XFILLER_0_2_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2150_ _0172_ _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__and2_1
X_2081_ _0119_ _0125_ _0111_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__mux2_1
X_1934_ _1071_ _1084_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__a21oi_1
X_1796_ _0915_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__nand2_1
X_1865_ _0899_ _0913_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__nand2_1
Xinput40 register_rs1[1] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
XFILLER_0_3_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput51 register_valid VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2348_ clknet_2_1__leaf_clk _0036_ VGND VGND VPWR VPWR u_posit_add.in1\[13\] sky130_fd_sc_hd__dfxtp_2
X_2279_ _0289_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1581_ _0710_ _0704_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__o21a_1
X_1650_ _0710_ _0640_ _0642_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__o21a_1
X_2202_ _0173_ _0176_ _0217_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2133_ _0174_ _0175_ _0105_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2064_ _0061_ _0064_ _1133_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1917_ _1070_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1848_ _0995_ _0996_ _0999_ _1001_ _0987_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__o32a_1
X_1779_ _0930_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__xor2_4
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1702_ _0672_ _0750_ _0839_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__and3_1
X_1633_ _0687_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__and2b_1
X_1564_ _0443_ _0438_ _0479_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1495_ _0591_ _0620_ _0647_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__a211o_1
X_2116_ _0112_ _0158_ _0126_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__or3_1
X_2047_ _0090_ _0091_ _1134_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1280_ _0413_ _0431_ _0432_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1547_ _0699_ _0700_ _0546_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__mux2_1
X_1616_ _0471_ _0479_ _0630_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__a21oi_1
X_1478_ _0625_ _0627_ _0629_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__o31a_1
XFILLER_0_49_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1401_ _0554_ _0441_ _0429_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_23_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1263_ u_posit_add.in2\[8\] _0415_ _0408_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__o31ai_4
X_1332_ _0445_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nor2_1
Xinput5 issue_req_instr[1] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_1194_ u_posit_add.in1\[14\] _0338_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__xor2_4
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1950_ _1073_ _1057_ _1070_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1881_ _0877_ _1029_ _1028_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1315_ u_posit_add.in2\[0\] _0411_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_22_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1177_ _0332_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2295_ net31 u_posit_add.in1\[8\] _0293_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__mux2_1
X_1246_ u_posit_add.in1\[0\] VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2080_ _0122_ _0124_ _0105_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__mux2_1
X_1933_ _1070_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput41 register_rs1[2] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
X_1795_ _0920_ _0921_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__and2_1
X_1864_ _0933_ _0940_ _0944_ _0972_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__and4_1
Xinput30 register_rs0[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
Xinput52 result_ready VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_58_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2347_ clknet_2_1__leaf_clk _0035_ VGND VGND VPWR VPWR u_posit_add.in1\[12\] sky130_fd_sc_hd__dfxtp_2
X_2278_ net17 u_posit_add.in1\[0\] _0280_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__mux2_1
X_1229_ _0339_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1580_ _0710_ _0707_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__nand2_1
X_2132_ _0094_ _1117_ _0135_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__mux2_1
X_2201_ _0236_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2063_ _1127_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1847_ _0991_ _1000_ _0989_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a21oi_1
X_1916_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__buf_2
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1778_ _0811_ _0807_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__mux2_2
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1701_ _0844_ _0847_ _0850_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1494_ _0561_ _0646_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__nor2_1
X_1563_ _0716_ _0455_ _0485_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__mux2_1
X_1632_ _0729_ _0735_ _0731_ _0635_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_55_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2115_ _0416_ _0931_ _0131_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__a21oi_4
X_2046_ _0089_ _1082_ _1096_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1546_ _0359_ _0355_ _0689_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__mux2_1
X_1615_ _0472_ _0485_ _0628_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__o21ai_1
X_1477_ _0471_ _0479_ _0558_ _0573_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__a2111o_1
X_2029_ _1089_ _0069_ _0070_ _0073_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__o211a_1
XFILLER_0_17_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1400_ _0551_ _0553_ _0464_ _0465_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__o211a_1
X_1331_ _0481_ _0482_ _0483_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o22a_2
XTAP_TAPCELL_ROW_59_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1262_ _0411_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__clkbuf_8
X_1193_ _0339_ _0342_ _0345_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nand3_1
Xinput6 issue_req_instr[27] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1529_ u_posit_add.in2\[14\] _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1880_ _1018_ _1014_ _1025_ _1027_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__o311ai_4
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2294_ _0297_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_1314_ u_posit_add.in2\[2\] _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1176_ _0328_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1245_ u_posit_add.in1\[1\] _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__xor2_2
XFILLER_0_42_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1932_ _0898_ _1085_ _1054_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1863_ _0974_ _1003_ _1005_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_33_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput20 register_rs0[12] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 register_rs0[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1794_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__inv_2
Xinput53 rst VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_2
Xinput42 register_rs1[3] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1228_ u_posit_add.in1\[5\] _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__xnor2_4
X_2346_ clknet_2_1__leaf_clk _0034_ VGND VGND VPWR VPWR u_posit_add.in1\[11\] sky130_fd_sc_hd__dfxtp_1
X_2277_ _0288_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1159_ _0317_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2131_ _0148_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__inv_2
X_2200_ _0130_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__and2_1
X_2062_ _1129_ _1128_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1846_ _0993_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__inv_2
X_1915_ _1059_ _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__and2_1
X_1777_ _0751_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2329_ clknet_2_3__leaf_clk _0017_ VGND VGND VPWR VPWR u_posit_add.in2\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1700_ _0728_ _0851_ _0852_ _0853_ _0780_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o311a_1
X_1631_ _0695_ _0744_ _0784_ _0688_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__o211a_1
XFILLER_0_39_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1493_ _0621_ _0646_ _0561_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__mux2_2
X_1562_ _0458_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__inv_2
X_2114_ _0156_ _0112_ _0158_ _0126_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__o31a_1
X_2045_ _0084_ _0089_ _1097_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1829_ _0977_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1614_ _0559_ _0766_ _0767_ _0635_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a211o_1
XFILLER_0_26_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1545_ _0382_ _0610_ _0404_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__mux2_1
X_1476_ _0481_ _0482_ _0483_ _0484_ _0470_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__o221a_1
X_2028_ _0071_ _0072_ _1070_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1261_ _0406_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_4
X_1330_ _0429_ _0441_ _0477_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_59_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput7 issue_req_instr[28] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1192_ _0339_ _0342_ _0345_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__or3_1
XFILLER_0_46_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1528_ _0415_ _0408_ _0409_ _0410_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or4_1
X_1459_ _0362_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__inv_2
XFILLER_0_37_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2293_ net30 u_posit_add.in1\[7\] _0293_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__mux2_1
X_1244_ u_posit_add.in1\[0\] u_posit_add.in1\[15\] VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__and2_1
X_1313_ u_posit_add.in2\[0\] u_posit_add.in2\[1\] _0411_ VGND VGND VPWR VPWR _0467_
+ sky130_fd_sc_hd__o21ai_4
X_1175_ current_state\[2\] _0325_ _0330_ current_state\[1\] VGND VGND VPWR VPWR _0331_
+ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1931_ _0998_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1793_ _0945_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__and2_1
X_1862_ _1012_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput21 register_rs0[13] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput32 register_rs0[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xinput10 issue_req_instr[30] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
Xinput43 register_rs1[4] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
X_1158_ net73 current_state\[1\] current_state\[2\] VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__or3_1
X_2345_ clknet_2_1__leaf_clk _0033_ VGND VGND VPWR VPWR u_posit_add.in1\[10\] sky130_fd_sc_hd__dfxtp_2
X_1227_ u_posit_add.in1\[4\] _0349_ _0377_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o21ai_2
X_2276_ net2 op _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2061_ _0093_ _0104_ _0105_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__mux2_1
X_2130_ _0111_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__buf_2
X_1914_ _1060_ _1061_ _1064_ _1066_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__o41a_1
X_1845_ _0843_ _0998_ _0898_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__o21a_1
X_1776_ _0900_ _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__xor2_4
XFILLER_0_8_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2328_ clknet_2_3__leaf_clk _0016_ VGND VGND VPWR VPWR u_posit_add.in2\[10\] sky130_fd_sc_hd__dfxtp_2
X_2259_ _0278_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1630_ _0695_ _0739_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nand2_1
X_1492_ _0624_ _0632_ _0637_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__o211ai_2
X_1561_ _0514_ _0714_ _0559_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__mux2_1
X_2044_ _1103_ _0087_ _1137_ _0069_ _0088_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__o221a_1
X_2113_ _0110_ _0105_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1828_ _0948_ _0965_ _0970_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__a21oi_1
X_1759_ _0825_ _0851_ _0852_ _0853_ _0844_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__o311a_1
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1613_ _0559_ _0634_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1544_ _0695_ _0697_ _0607_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21oi_1
X_1475_ _0472_ _0485_ _0558_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__o211a_1
X_2027_ _0976_ _0981_ _1054_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1260_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__buf_6
Xinput8 issue_req_instr[29] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_1191_ u_posit_add.in1\[11\] _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_59_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1527_ _0677_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1389_ _0380_ _0383_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__or2_1
X_1458_ _0610_ _0596_ _0545_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1174_ current_state\[0\] net73 current_state\[2\] _0329_ VGND VGND VPWR VPWR _0330_
+ sky130_fd_sc_hd__or4_1
X_2292_ _0296_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_1243_ u_posit_add.in1\[2\] _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__xor2_2
X_1312_ _0456_ _0459_ _0464_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and4b_1
XFILLER_0_59_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1930_ _1083_ _0894_ _1054_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1861_ _0933_ _0940_ _0944_ _0972_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a41o_1
XPHY_EDGE_ROW_26_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput22 register_rs0[14] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput11 issue_req_instr[31] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
Xinput44 register_rs1[5] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1792_ _0832_ _0831_ _0751_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__mux2_1
Xinput33 register_rs1[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2344_ clknet_2_1__leaf_clk _0032_ VGND VGND VPWR VPWR u_posit_add.in1\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1226_ _0371_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__xnor2_1
X_1157_ net52 net73 _0317_ net53 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__a211o_1
X_2275_ net53 _0005_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2060_ _0060_ _0065_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__xor2_4
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1913_ _0976_ _0974_ _1049_ _1016_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__a211o_1
XFILLER_0_44_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1844_ _0866_ _0997_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__xnor2_2
X_1775_ _0895_ _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__nand2_2
XFILLER_0_8_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2327_ clknet_2_3__leaf_clk _0015_ VGND VGND VPWR VPWR u_posit_add.in2\[9\] sky130_fd_sc_hd__dfxtp_2
X_2258_ net47 u_posit_add.in2\[8\] _0269_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2189_ _0217_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nand2_1
X_1209_ u_posit_add.in1\[8\] _0349_ _0335_ u_posit_add.in1\[15\] VGND VGND VPWR VPWR
+ _0363_ sky130_fd_sc_hd__o31a_1
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1560_ _0513_ _0432_ _0479_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__mux2_1
X_2112_ _0135_ _1135_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__nand2_1
X_1491_ _0569_ _0640_ _0642_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__o211ai_1
X_2043_ _1138_ _1101_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__or2b_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1827_ _0978_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1689_ _0673_ _0782_ _0815_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__o31ai_4
X_1758_ _0781_ _0847_ _0850_ _0841_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_13_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1612_ _0436_ _0479_ _0641_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1543_ _0614_ _0696_ _0599_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__mux2_1
X_1474_ _0442_ _0453_ _0475_ _0478_ _0463_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a221o_1
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2026_ _1062_ _0974_ _1054_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput9 issue_req_instr[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
X_1190_ u_posit_add.in1\[10\] _0333_ _0335_ _0343_ u_posit_add.in1\[15\] VGND VGND
+ VPWR VPWR _0344_ sky130_fd_sc_hd__o41a_2
XFILLER_0_52_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1526_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__inv_2
X_1457_ _0369_ _0376_ _0390_ _0403_ _0355_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o221a_1
X_1388_ _0339_ _0397_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__o31a_1
X_2009_ _0049_ _0053_ _1096_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2291_ net29 u_posit_add.in1\[6\] _0293_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1311_ _0414_ _0461_ _0463_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_59_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1173_ pau_wait_counter\[1\] pau_wait_counter\[0\] VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ u_posit_add.in1\[0\] u_posit_add.in1\[1\] _0377_ VGND VGND VPWR VPWR _0396_
+ sky130_fd_sc_hd__o21ai_2
X_1509_ _0659_ _0658_ _0561_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1860_ _0933_ _0938_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_1_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1791_ _0904_ _0927_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__xnor2_1
Xinput34 register_rs1[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 register_rs1[6] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput23 register_rs0[15] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput12 issue_req_instr[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2274_ _0286_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_2343_ clknet_2_1__leaf_clk _0031_ VGND VGND VPWR VPWR u_posit_add.in1\[8\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_47_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1225_ u_posit_add.in1\[6\] _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__xnor2_4
X_1156_ current_state\[0\] _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__and2_1
X_1989_ _1140_ _1142_ _1097_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1843_ _0877_ _0843_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__nor2_1
X_1912_ _0994_ _1065_ _0990_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__o21ba_1
X_1774_ _0905_ _0908_ _0910_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__or4b_2
XFILLER_0_8_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2326_ clknet_2_3__leaf_clk _0014_ VGND VGND VPWR VPWR u_posit_add.in2\[8\] sky130_fd_sc_hd__dfxtp_4
X_1208_ u_posit_add.in1\[10\] _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__xnor2_4
X_2257_ _0277_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
X_2188_ _0151_ _0125_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1490_ _0574_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__nor2_1
X_2111_ _0152_ _0153_ _0154_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__and4_1
X_2042_ _1093_ _0072_ _1071_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1826_ _0979_ _0971_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1688_ _0781_ _0826_ _0835_ _0840_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__a311o_1
X_1757_ _0861_ _0864_ _0781_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2309_ net23 _0377_ _0268_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1611_ _0764_ _0640_ _0710_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1542_ _0613_ _0364_ _0596_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__mux2_1
X_1473_ _0461_ _0485_ _0569_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__o211a_1
X_2025_ _1081_ _1094_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1809_ _0945_ _0946_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1525_ _0647_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__xor2_4
XFILLER_0_10_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1387_ _0400_ _0348_ _0503_ _0399_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__or4_1
X_1456_ _0379_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__inv_2
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2008_ _0052_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__inv_2
XFILLER_0_45_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2290_ _0295_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_1241_ _0393_ _0394_ _0380_ _0383_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a211o_1
X_1310_ _0413_ _0461_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a21bo_1
X_1172_ _0323_ _0326_ _0327_ _0328_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__o211a_1
XFILLER_0_2_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1508_ _0535_ _0562_ _0576_ _0489_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a31o_1
X_1439_ _0353_ _0367_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1790_ _0942_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__nand2_1
Xinput13 issue_req_instr[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
Xinput35 register_rs1[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput24 register_rs0[1] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput46 register_rs1[7] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2273_ net39 _0416_ _0280_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__mux2_1
X_2342_ clknet_2_1__leaf_clk _0030_ VGND VGND VPWR VPWR u_posit_add.in1\[7\] sky130_fd_sc_hd__dfxtp_2
X_1224_ u_posit_add.in1\[5\] u_posit_add.in1\[4\] _0349_ _0377_ VGND VGND VPWR VPWR
+ _0378_ sky130_fd_sc_hd__o31a_2
XFILLER_0_59_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1155_ _0313_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__or2_1
X_1988_ _1072_ _1103_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_50_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1842_ _0894_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__inv_2
X_1911_ _0896_ _0894_ _0898_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__and3_1
X_1773_ _0915_ _0920_ _0921_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__and4_1
XFILLER_0_12_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2187_ _0200_ _0204_ _0218_ _0210_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__or4b_2
XFILLER_0_40_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1207_ _0349_ _0335_ _0343_ u_posit_add.in1\[15\] VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o31a_2
X_2325_ clknet_2_2__leaf_clk _0013_ VGND VGND VPWR VPWR u_posit_add.in2\[7\] sky130_fd_sc_hd__dfxtp_1
X_2256_ net46 u_posit_add.in2\[7\] _0269_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2110_ _0143_ _0059_ _0137_ _0118_ _0138_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__a41o_1
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2041_ _0080_ _0085_ _1134_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1825_ _0944_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__inv_2
X_1756_ _0899_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1687_ _0655_ _0672_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nand2_4
X_2308_ _0304_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
X_2239_ net73 current_state\[1\] _0327_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_0_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1610_ _0461_ _0485_ _0626_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__o21ai_1
X_1541_ _0595_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__buf_2
X_1472_ _0442_ _0453_ _0475_ _0478_ _0458_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__a221o_1
X_2024_ _0068_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_37_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1808_ _0957_ _0960_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__a21o_1
X_1739_ _0890_ _0891_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1524_ _0591_ _0620_ _0648_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1386_ u_posit_add.in1\[1\] _0398_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__xnor2_1
X_1455_ _0359_ _0596_ _0599_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a211o_1
X_2007_ _1103_ _1137_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1171_ net53 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__inv_2
X_1240_ _0371_ _0386_ _0392_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_47_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1507_ _0657_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1438_ _0349_ _0335_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nor2_1
X_1369_ _0519_ _0518_ _0515_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_53_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput36 register_rs1[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_1
Xinput14 issue_req_instr[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput25 register_rs0[2] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput47 register_rs1[8] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_2341_ clknet_2_0__leaf_clk _0029_ VGND VGND VPWR VPWR u_posit_add.in1\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_24_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2272_ _0285_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_1223_ u_posit_add.in1\[15\] VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__clkbuf_8
X_1154_ net8 _0314_ net11 net16 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__or4b_1
XFILLER_0_59_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1987_ _1106_ _1140_ _1097_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1910_ _1062_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1841_ _0990_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__or2_1
X_1772_ _0895_ _0925_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2324_ clknet_2_3__leaf_clk _0012_ VGND VGND VPWR VPWR u_posit_add.in2\[6\] sky130_fd_sc_hd__dfxtp_2
X_2186_ _0160_ _0222_ _0223_ _0172_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__o211a_1
X_1206_ _0348_ _0359_ _0355_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and3_1
X_2255_ _0276_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2040_ _0074_ _0084_ _1097_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1824_ _0968_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1755_ _0844_ _0872_ _0873_ _0874_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__a31o_1
X_1686_ _0783_ _0728_ _0836_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__and4_1
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2307_ net22 u_posit_add.in1\[14\] _0268_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__mux2_1
X_2238_ net2 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__inv_2
X_2169_ _0105_ _0175_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_0_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1540_ _0692_ _0693_ _0567_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__mux2_1
X_1471_ _0573_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__inv_2
X_2023_ _0995_ _1099_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_37_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1807_ _0958_ _0959_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1738_ _0890_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__nand2_2
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1669_ _0687_ _0820_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1523_ _0584_ _0656_ _0665_ _0670_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__o31ai_4
X_1454_ _0369_ _0376_ _0390_ _0403_ _0364_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__o221a_1
XFILLER_0_22_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1385_ _0393_ _0394_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__nand2_1
X_2006_ _0048_ _0050_ _1135_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1170_ current_state\[0\] _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1506_ _0658_ _0659_ _0561_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__mux2_1
X_1437_ _0561_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1299_ _0429_ _0448_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a21oi_1
X_1368_ _0510_ _0512_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_53_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput37 register_rs1[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput48 register_rs1[9] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput15 issue_req_instr[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput26 register_rs0[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2271_ net38 u_posit_add.in2\[14\] _0280_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__mux2_1
X_2340_ clknet_2_1__leaf_clk _0028_ VGND VGND VPWR VPWR u_posit_add.in1\[5\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_9_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1222_ _0353_ _0374_ _0375_ _0352_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__a22o_2
X_1153_ net3 net7 net6 net10 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__or4_1
X_1986_ _1139_ _1100_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_50_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1840_ _0991_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1771_ _0841_ _0922_ _0923_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2323_ clknet_2_2__leaf_clk _0011_ VGND VGND VPWR VPWR u_posit_add.in2\[5\] sky130_fd_sc_hd__dfxtp_2
X_2254_ net45 u_posit_add.in2\[6\] _0269_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2185_ _0133_ _0221_ _0219_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1205_ u_posit_add.in1\[8\] _0356_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__xor2_2
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1969_ _0577_ _1100_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__xor2_4
XFILLER_0_7_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1823_ _0948_ _0965_ _0970_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1754_ _0906_ _0907_ _0895_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__o21a_1
XFILLER_0_40_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1685_ _0837_ _0838_ _0687_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__mux2_1
X_2237_ _0172_ _0133_ _0129_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__a21o_1
X_2306_ _0303_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_2099_ _0142_ _0143_ _0138_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__mux2_1
X_2168_ _0160_ _0205_ _0206_ _0207_ _0172_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__o311a_1
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1470_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ _0046_ _0059_ _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1806_ _0958_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1599_ _0400_ _0689_ _0604_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a21oi_1
X_1668_ _0591_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and2b_1
X_1737_ _0838_ _0837_ _0751_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1522_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__buf_2
X_1453_ _0592_ _0593_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nor2_2
X_2005_ _0047_ _0049_ _1097_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__mux2_1
X_1384_ _0353_ _0536_ _0537_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1436_ _0586_ _0587_ _0588_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__o211ai_4
X_1367_ _0515_ _0516_ _0518_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__or4_1
X_1505_ _0371_ _0379_ _0594_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_53_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1298_ _0449_ _0451_ _0428_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput38 register_rs1[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
Xinput27 register_rs0[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput16 issue_valid VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput49 register_rs_valid[0] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2270_ _0284_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_1221_ _0340_ _0342_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_9_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1152_ _0311_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__nand2_1
X_1985_ _1137_ _1138_ _1081_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_50_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_21_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1419_ _0441_ _0572_ _0429_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1770_ _0781_ _0867_ _0868_ _0899_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__o31a_1
XFILLER_0_29_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2184_ _0219_ _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nand2_1
X_1204_ _0355_ _0357_ _0339_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and3b_1
X_2253_ _0275_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2322_ clknet_2_3__leaf_clk _0010_ VGND VGND VPWR VPWR u_posit_add.in2\[4\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_47_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1899_ _1041_ _1046_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__or3b_2
XFILLER_0_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1968_ _1118_ _1081_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__or2b_2
XFILLER_0_38_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1822_ _0940_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1753_ _0782_ _0815_ _0899_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1684_ _0607_ _0810_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__nor2_1
X_2167_ _0160_ _0206_ _0205_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2236_ _0264_ _0265_ _0266_ _0172_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_0_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2305_ net21 u_posit_add.in1\[13\] _0293_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__mux2_1
X_2098_ _0114_ _0116_ _0135_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2021_ _0060_ _0065_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1736_ _0878_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__xor2_1
X_1805_ _0817_ _0816_ _0751_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1598_ _0503_ _0689_ _0602_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__a21o_1
X_1667_ _0635_ _0735_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__or2_1
X_2219_ _0250_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1521_ _0584_ _0656_ _0665_ _0670_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__o311a_2
X_1383_ _0371_ _0342_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__xnor2_1
X_1452_ _0595_ _0601_ _0603_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__a31o_1
X_2004_ _1070_ _1055_ _1103_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__or3_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1719_ _0675_ _0749_ _0776_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__or3_1
XFILLER_0_6_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1504_ _0445_ _0638_ _0624_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1435_ _0490_ _0578_ _0579_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__o21ai_2
X_1366_ _0436_ _0357_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_53_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1297_ _0445_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput39 register_rs1[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
Xinput17 register_rs0[0] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 register_rs0[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
X_1220_ _0365_ _0366_ _0370_ _0372_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__a41o_1
X_1151_ net9 net12 net1 net5 VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_9_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1984_ _1091_ _1084_ _1070_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1349_ u_posit_add.in1\[2\] _0396_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__xnor2_2
X_1418_ _0466_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_6_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2321_ clknet_2_2__leaf_clk _0009_ VGND VGND VPWR VPWR u_posit_add.in2\[3\] sky130_fd_sc_hd__dfxtp_1
X_2183_ _0211_ _0212_ _0196_ _0197_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__a2111o_1
X_1203_ u_posit_add.in1\[8\] _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__xnor2_2
X_2252_ net44 u_posit_add.in2\[5\] _0269_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1967_ _1111_ _1115_ _1110_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__a21o_1
X_1898_ _1032_ _1051_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1821_ _0944_ _0972_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nand2_1
X_1752_ _0899_ _0855_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1683_ _0710_ _0770_ _0713_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__and3_1
X_2304_ _0302_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_2097_ _0121_ _0113_ _0135_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__mux2_1
X_2166_ _0196_ _0197_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2235_ _0259_ _0260_ _0265_ _0133_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_31_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2020_ _0062_ _0064_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_45_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1804_ _0914_ _0949_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__xor2_1
X_1735_ _0673_ _0882_ _0885_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1666_ _0567_ _0607_ _0744_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__or3b_1
XFILLER_0_56_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1597_ _0591_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__clkbuf_4
X_2149_ _0189_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__xnor2_1
X_2218_ _0243_ _0244_ _0248_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1520_ _0649_ _0650_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1382_ _0365_ _0366_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand2_1
X_1451_ _0400_ _0596_ _0599_ _0595_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a2111oi_1
X_2003_ _1142_ _0047_ _1097_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1718_ _0728_ _0802_ _0813_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__or3_1
X_1649_ _0627_ _0629_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1503_ _0578_ _0579_ _0581_ _0490_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a31o_1
XFILLER_0_10_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1296_ u_posit_add.in2\[13\] _0421_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__xor2_2
X_1434_ _0490_ _0578_ _0579_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__or3_2
X_1365_ _0513_ _0362_ _0432_ _0517_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__o22a_1
XFILLER_0_33_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 register_rs0[10] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput29 register_rs0[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
X_1150_ net4 net15 net14 net13 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_9_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1983_ _1070_ _1086_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1417_ u_posit_add.in2\[0\] u_posit_add.in2\[2\] u_posit_add.in2\[1\] _0445_ VGND
+ VGND VPWR VPWR _0571_ sky130_fd_sc_hd__or4_1
X_1279_ _0414_ _0431_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1348_ _0386_ _0461_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_6_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2320_ clknet_2_0__leaf_clk _0008_ VGND VGND VPWR VPWR u_posit_add.in2\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_20_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2251_ _0274_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_2182_ _0200_ _0203_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__xnor2_1
X_1202_ _0349_ _0335_ u_posit_add.in1\[15\] VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1966_ _1108_ _1119_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1897_ _1018_ _1014_ _1025_ _1027_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__o31a_1
XFILLER_0_7_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1820_ _0933_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1751_ _0877_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__nor2_1
X_1682_ _0672_ _0750_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nand2_1
X_2234_ _0251_ _0257_ _1133_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_29_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2303_ net20 u_posit_add.in1\[12\] _0293_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__mux2_1
X_2096_ _0122_ _0115_ _0138_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__mux2_1
X_2165_ _0200_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_0_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1949_ _1100_ _1081_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0954_ _0955_ _0892_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_45_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1734_ _0886_ _0887_ _0783_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1596_ _0679_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__buf_2
X_1665_ _0672_ _0750_ _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2217_ _0243_ _0244_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2148_ _0179_ _0180_ _0132_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2079_ _1116_ _0123_ _0045_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1450_ _0369_ _0376_ _0390_ _0403_ _0540_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__o221a_1
XFILLER_0_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1381_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__clkbuf_4
X_2002_ _1089_ _1103_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1717_ _0783_ _0867_ _0868_ _0869_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__o32a_1
X_1648_ _0801_ _0679_ _0671_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__and3b_1
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1579_ _0559_ _0718_ _0732_ _0635_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_38_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1433_ _0489_ _0535_ _0562_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__o21a_1
X_1502_ _0577_ _0582_ _0590_ _0652_ _0653_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_37_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1295_ _0414_ _0422_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nor2_1
X_1364_ _0432_ _0517_ _0436_ _0357_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 register_rs0[11] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1982_ _1098_ _1107_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1416_ _0480_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__nand2_1
X_1347_ _0458_ _0382_ _0386_ _0461_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__o22a_1
X_1278_ u_posit_add.in2\[9\] _0417_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_14_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1201_ u_posit_add.in1\[7\] _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__xor2_4
XFILLER_0_20_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2250_ net43 u_posit_add.in2\[4\] _0269_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__mux2_1
X_2181_ _0211_ _0218_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_25_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1965_ _1118_ _1080_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1896_ _1041_ _1046_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_3_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1750_ _0899_ _0901_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_25_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1681_ _0825_ _0830_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__nand3_1
X_2164_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__inv_2
X_2233_ _0259_ _0260_ _0133_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__o21a_1
X_2302_ _0301_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_2095_ _0093_ _0046_ _0138_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1948_ _1070_ _1055_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__nor2_1
X_1879_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1802_ _0954_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_45_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1733_ _0848_ _0849_ _0676_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a21o_1
X_1595_ _0748_ _0679_ _0727_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__and3b_1
X_1664_ _0816_ _0817_ _0591_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2147_ _0187_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__nand2_1
X_2216_ _0184_ _0217_ _0248_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__and3_1
X_2078_ _1147_ _0101_ _1134_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1380_ _0405_ _0487_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2001_ _1136_ _1144_ _0045_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1716_ _0825_ _0819_ _0824_ _0780_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1578_ _0559_ _0714_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__nor2_1
X_1647_ _0687_ _0797_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1501_ _0585_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__xnor2_2
X_1432_ _0489_ _0535_ _0562_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nor3_2
X_1363_ u_posit_add.in1\[9\] _0363_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1294_ _0433_ _0434_ _0444_ _0446_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__a41o_1
XFILLER_0_33_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1981_ _1134_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__buf_6
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1346_ _0496_ _0497_ _0498_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__or4_1
X_1415_ _0442_ _0557_ _0555_ _0550_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__o2bb2a_1
X_1277_ u_posit_add.in2\[10\] _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_3_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2180_ _0151_ _0106_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__a21bo_1
X_1200_ u_posit_add.in1\[5\] u_posit_add.in1\[4\] u_posit_add.in1\[6\] _0349_ u_posit_add.in1\[15\]
+ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__o41a_2
XPHY_EDGE_ROW_0_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1895_ _1047_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__xor2_1
X_1964_ _0586_ _0587_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1329_ _0466_ _0474_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1680_ _0672_ _0750_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a21o_1
X_2301_ net19 u_posit_add.in1\[11\] _0293_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__mux2_1
X_2163_ _0201_ _0202_ _0111_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2232_ _0263_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_2094_ _0136_ _0137_ _0138_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1947_ _1081_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__and2b_1
X_1878_ _1030_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1732_ _0862_ _0863_ _0825_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1663_ _0695_ _0688_ _0754_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__and3_1
X_1801_ _0820_ _0821_ _0751_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__mux2_2
XFILLER_0_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1594_ _0687_ _0737_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_56_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2146_ _0168_ _0178_ _0186_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__o21bai_1
X_2077_ _0120_ _0121_ _0045_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__mux2_1
X_2215_ _0173_ _0193_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_36_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2000_ _1149_ _0044_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_45_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xcvxif_pau_90 VGND VGND VPWR VPWR cvxif_pau_90/HI result_data[31] sky130_fd_sc_hd__conb_1
X_1715_ _0676_ _0836_ _0839_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1646_ _0591_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__and2b_1
X_1577_ _0710_ _0717_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__a21oi_1
X_2129_ _0160_ _0163_ _0170_ _0171_ _0172_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__o311a_1
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1500_ _0590_ _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1431_ _0583_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__or2_1
X_1293_ _0445_ _0431_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__xnor2_1
X_1362_ _0514_ _0345_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1629_ _0727_ _0779_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1980_ _1117_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_23_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1276_ u_posit_add.in2\[9\] u_posit_add.in2\[8\] _0415_ _0408_ _0411_ VGND VGND VPWR
+ VPWR _0430_ sky130_fd_sc_hd__o41a_2
X_1345_ _0438_ _0355_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__and2_1
X_1414_ _0547_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1963_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__inv_2
X_1894_ _1011_ _1015_ _1010_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1259_ u_posit_add.in2\[14\] _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__xnor2_4
X_1328_ _0429_ _0448_ _0452_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_3_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2231_ _0261_ _0262_ _0130_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and3b_1
XFILLER_0_29_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2300_ _0300_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_2093_ _0066_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__buf_2
X_2162_ _0138_ _0164_ _0184_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_45_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1946_ _0995_ _1078_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1877_ _0703_ _0722_ _0931_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_39_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1800_ _0919_ _0921_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1731_ _0883_ _0884_ _0673_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__o21a_1
XFILLER_0_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1662_ _0713_ _0771_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2214_ _0245_ _0246_ _0247_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1593_ _0746_ _0591_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__or2b_1
X_2076_ _0085_ _0090_ _1134_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__mux2_1
X_2145_ _0168_ _0178_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_36_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1929_ _0991_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_55_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xcvxif_pau_91 VGND VGND VPWR VPWR issue_resp_register_read[0] cvxif_pau_91/LO sky130_fd_sc_hd__conb_1
Xcvxif_pau_80 VGND VGND VPWR VPWR cvxif_pau_80/HI result_data[21] sky130_fd_sc_hd__conb_1
XFILLER_0_53_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1714_ _0830_ _0834_ _0825_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1576_ _0710_ _0708_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1645_ _0574_ _0711_ _0720_ _0635_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__o221a_1
X_2128_ _0130_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__buf_2
X_2059_ _0096_ _0103_ _0045_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1430_ _0577_ _0582_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nor2_2
XFILLER_0_10_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1361_ _0513_ _0362_ _0514_ _0345_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a22o_1
X_1292_ _0445_ _0436_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1628_ _0676_ _0726_ _0777_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1559_ _0625_ _0643_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_52_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1413_ _0564_ _0566_ _0353_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__o21a_2
XFILLER_0_23_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1275_ _0423_ _0424_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_3_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1344_ _0379_ _0455_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1962_ _1112_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1893_ _1026_ _1024_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_11_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1258_ _0406_ _0408_ _0409_ _0410_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__o41a_4
X_1189_ u_posit_add.in1\[9\] u_posit_add.in1\[8\] VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_3_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1327_ _0429_ _0441_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_29_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2230_ _0133_ _0260_ _0259_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__a21o_1
X_2092_ _1144_ _0051_ _0135_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__mux2_1
X_2161_ _0147_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__inv_2
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1945_ _1060_ _1061_ _1064_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__nor3_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1876_ _1028_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__xor2_2
XFILLER_0_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1661_ _0783_ _0795_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__and3_1
X_1730_ _0728_ _0859_ _0860_ _0780_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1592_ _0742_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2144_ _0183_ _0185_ _0111_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__mux2_1
X_2213_ _0245_ _0246_ _0172_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__o21ai_1
X_2075_ _0102_ _0080_ _1135_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1928_ _1072_ _1077_ _1081_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1859_ _0930_ _0932_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1713_ _0789_ _0794_ _0676_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xcvxif_pau_92 VGND VGND VPWR VPWR issue_resp_writeback cvxif_pau_92/LO sky130_fd_sc_hd__conb_1
Xcvxif_pau_81 VGND VGND VPWR VPWR cvxif_pau_81/HI result_data[22] sky130_fd_sc_hd__conb_1
XFILLER_0_6_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1644_ _0574_ _0705_ _0624_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1575_ _0574_ _0643_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__or2_1
X_2127_ _0160_ _0163_ _0170_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2058_ _0101_ _0102_ _1134_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput70 net70 VGND VGND VPWR VPWR result_data[7] sky130_fd_sc_hd__buf_1
X_1360_ _0419_ _0420_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2_2
XFILLER_0_37_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1291_ _0425_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1627_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__buf_2
X_1558_ _0705_ _0711_ _0574_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__mux2_1
X_1489_ _0622_ _0442_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1412_ _0384_ _0539_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__and3_1
X_1343_ _0438_ _0355_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1274_ _0425_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1961_ _1096_ _1056_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a21oi_1
X_1892_ _1044_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1326_ _0414_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nor2_1
X_1188_ u_posit_add.in1\[13\] _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_19_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1257_ u_posit_add.in2\[15\] VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2160_ _0168_ _0178_ _0186_ _0195_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__nand4bb_4
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2091_ _0092_ _1136_ _0135_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__mux2_1
X_1944_ _1082_ _1095_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1875_ _0655_ _0922_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2289_ net28 u_posit_add.in1\[5\] _0293_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__mux2_1
X_1309_ u_posit_add.in2\[3\] _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1660_ _0675_ _0802_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1591_ _0695_ _0744_ _0688_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a21oi_1
X_2143_ _0138_ _0104_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__a21boi_1
X_2212_ _0238_ _0239_ _0133_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__o21a_1
X_2074_ _0115_ _0118_ _0066_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1858_ _1010_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or2b_1
X_1927_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__buf_2
XFILLER_0_31_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1789_ _0792_ _0790_ _0931_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xcvxif_pau_82 VGND VGND VPWR VPWR cvxif_pau_82/HI result_data[23] sky130_fd_sc_hd__conb_1
XFILLER_0_53_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1712_ _0841_ _0855_ _0858_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_1 _0513_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1643_ _0695_ _0693_ _0796_ _0688_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__a22o_1
X_1574_ _0727_ _0674_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__nand2_2
XFILLER_0_6_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2126_ _0168_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__nand2_1
X_2057_ _0079_ _0099_ _1041_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput71 net71 VGND VGND VPWR VPWR result_data[8] sky130_fd_sc_hd__buf_1
Xoutput60 net60 VGND VGND VPWR VPWR result_data[12] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_33_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1290_ _0414_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1626_ _0672_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1488_ _0436_ _0479_ _0559_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__a211o_1
X_1557_ _0707_ _0709_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__mux2_1
X_2109_ _1097_ _1085_ _1135_ _0057_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o22a_1
XFILLER_0_32_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1273_ u_posit_add.in2\[12\] _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__xnor2_4
X_1411_ u_posit_add.in1\[0\] u_posit_add.in1\[1\] u_posit_add.in1\[2\] _0371_ VGND
+ VGND VPWR VPWR _0565_ sky130_fd_sc_hd__or4_1
X_1342_ _0458_ _0382_ _0379_ _0455_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1609_ _0695_ _0607_ _0754_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1891_ _1042_ _1034_ _1043_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__a21oi_1
X_1960_ _0931_ _0620_ _1113_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_28_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1256_ u_posit_add.in2\[13\] u_posit_add.in2\[12\] VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__or2_1
X_1325_ _0442_ _0453_ _0475_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a22o_2
X_1187_ u_posit_add.in1\[12\] _0333_ _0335_ _0336_ u_posit_add.in1\[15\] VGND VGND
+ VPWR VPWR _0341_ sky130_fd_sc_hd__o41a_2
XPHY_EDGE_ROW_20_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2090_ _0045_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1943_ _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1874_ _1006_ _1007_ _1019_ _0877_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_3_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2288_ _0294_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_1239_ _0339_ _0388_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__or3b_1
X_2357_ clknet_2_0__leaf_clk _0004_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_2
X_1308_ u_posit_add.in2\[0\] u_posit_add.in2\[2\] u_posit_add.in2\[1\] _0411_ VGND
+ VGND VPWR VPWR _0462_ sky130_fd_sc_hd__o31a_1
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1590_ _0690_ _0743_ _0599_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__mux2_1
X_2073_ _0116_ _0117_ _0045_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__mux2_1
X_2142_ _1133_ _0105_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__nand2_1
X_2211_ _0243_ _0244_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_44_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1926_ _0984_ _1079_ _1064_ _1061_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__a211o_1
X_1788_ _0906_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__xnor2_1
X_1857_ _1008_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_42_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1711_ _0781_ _0861_ _0864_ _0841_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a31o_1
Xcvxif_pau_83 VGND VGND VPWR VPWR cvxif_pau_83/HI result_data[24] sky130_fd_sc_hd__conb_1
X_1642_ _0701_ _0692_ _0567_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__mux2_1
X_1573_ _0671_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__buf_6
X_2125_ _0112_ _0158_ _0126_ _0166_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__o31ai_1
X_2056_ _1097_ _0099_ _0100_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1909_ _1047_ _1048_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput72 net72 VGND VGND VPWR VPWR result_data[9] sky130_fd_sc_hd__buf_1
Xoutput61 net61 VGND VGND VPWR VPWR result_data[13] sky130_fd_sc_hd__buf_1
XFILLER_0_37_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1625_ _0778_ _0652_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1556_ _0569_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__buf_2
X_1487_ _0481_ _0482_ _0483_ _0484_ _0432_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__o221a_1
X_2108_ _0058_ _0117_ _0135_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__a21o_1
X_2039_ _0068_ _1102_ _0082_ _0083_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_49_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1410_ _0358_ _0360_ _0536_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_2_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1272_ _0415_ _0408_ _0409_ _0416_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__o31a_2
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1341_ _0493_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1539_ u_posit_add.in1\[0\] _0404_ _0546_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__and3_1
X_1608_ _0695_ _0757_ _0761_ _0688_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__o211a_1
XFILLER_0_49_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1890_ _1042_ _1034_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1255_ u_posit_add.in2\[11\] u_posit_add.in2\[10\] u_posit_add.in2\[9\] u_posit_add.in2\[8\]
+ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__or4_2
X_1186_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_19_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1324_ _0429_ _0441_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1942_ _1034_ _1038_ _1040_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__a21o_2
XFILLER_0_43_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1873_ _1024_ _1011_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2356_ clknet_2_0__leaf_clk _0003_ VGND VGND VPWR VPWR current_state\[2\] sky130_fd_sc_hd__dfxtp_1
X_1169_ _0325_ current_state\[2\] VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__and2b_1
X_2287_ net27 u_posit_add.in1\[4\] _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__mux2_1
X_1238_ u_posit_add.in1\[3\] _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__xor2_4
X_1307_ u_posit_add.in2\[4\] _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__xor2_4
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2210_ _0173_ _0185_ _0217_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__o21a_1
X_2072_ _0050_ _0054_ _1135_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__mux2_1
X_2141_ _0140_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__inv_2
X_1925_ _0990_ _0994_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_44_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1787_ _0934_ _0907_ _0895_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__o21a_1
X_1856_ _1008_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2339_ clknet_2_1__leaf_clk _0027_ VGND VGND VPWR VPWR u_posit_add.in1\[4\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_47_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xcvxif_pau_84 VGND VGND VPWR VPWR cvxif_pau_84/HI result_data[25] sky130_fd_sc_hd__conb_1
XFILLER_0_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1572_ _0681_ _0686_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__o21a_1
X_1710_ _0862_ _0863_ _0676_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__a21o_1
X_1641_ _0676_ _0789_ _0794_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nand3_1
XFILLER_0_6_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2124_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__buf_6
X_2055_ _1096_ _1046_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__nor2_1
X_1839_ _0957_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__xnor2_2
X_1908_ _1016_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__inv_2
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput62 net62 VGND VGND VPWR VPWR result_data[14] sky130_fd_sc_hd__buf_1
Xoutput73 net73 VGND VGND VPWR VPWR result_valid sky130_fd_sc_hd__buf_1
XFILLER_0_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1624_ _0653_ _0590_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__and2b_1
X_1555_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__inv_2
X_2107_ _0139_ _0145_ _0150_ _0151_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a31o_1
X_1486_ _0638_ _0479_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__a21oi_1
X_2038_ _1081_ _1104_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1340_ _0450_ _0342_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1271_ u_posit_add.in2\[14\] _0412_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__xor2_4
XFILLER_0_46_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1538_ _0690_ _0691_ _0546_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__mux2_1
X_1607_ _0695_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nand2_1
X_1469_ _0622_ _0442_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1323_ _0459_ _0476_ _0456_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__a21oi_1
X_1185_ u_posit_add.in1\[14\] _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_19_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1254_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__buf_2
XFILLER_0_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1941_ _1089_ _1094_ _1081_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__mux2_1
X_1872_ _1021_ _1022_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_16_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2355_ clknet_2_0__leaf_clk _0002_ VGND VGND VPWR VPWR current_state\[1\] sky130_fd_sc_hd__dfxtp_1
X_2286_ _0268_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_4
X_1306_ _0411_ _0415_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__nand2_2
X_1237_ u_posit_add.in1\[0\] u_posit_add.in1\[1\] u_posit_add.in1\[2\] _0377_ VGND
+ VGND VPWR VPWR _0391_ sky130_fd_sc_hd__o31a_1
X_1168_ net50 op net51 _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__o211a_1
XFILLER_0_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2140_ _0160_ _0181_ _0182_ _0172_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__o211a_1
X_2071_ _1143_ _0048_ _1135_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1924_ _0896_ _0996_ _0876_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_44_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1855_ _0746_ _0737_ _0931_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__mux2_1
X_1786_ _0938_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nor2_2
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2269_ net37 u_posit_add.in2\[13\] _0280_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__mux2_1
X_2338_ clknet_2_0__leaf_clk _0026_ VGND VGND VPWR VPWR u_posit_add.in1\[3\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_47_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xcvxif_pau_85 VGND VGND VPWR VPWR cvxif_pau_85/HI result_data[26] sky130_fd_sc_hd__conb_1
Xcvxif_pau_74 VGND VGND VPWR VPWR cvxif_pau_74/HI register_ready sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_41_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1640_ _0672_ _0750_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__a21o_1
X_1571_ _0677_ _0680_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__or3_1
XFILLER_0_21_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2123_ _0112_ _0158_ _0126_ _0166_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_49_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2054_ _1081_ _0087_ _1139_ _1100_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_32_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1838_ _0961_ _0960_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__or2b_1
X_1907_ _1052_ _1041_ _1044_ _1045_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__or4_1
XFILLER_0_8_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1769_ _0872_ _0873_ _0844_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput63 net63 VGND VGND VPWR VPWR result_data[15] sky130_fd_sc_hd__buf_1
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1623_ _0728_ _0749_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__or3_1
X_1554_ _0461_ _0463_ _0479_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__mux2_1
X_1485_ _0481_ _0482_ _0483_ _0484_ _0438_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__o221a_1
.ends
